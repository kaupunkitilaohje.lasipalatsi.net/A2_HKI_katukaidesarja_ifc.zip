Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2016-12-07T13:27:02
Author: Katajamäki, Jokke
Organization: WSP Finland
Made in: ASIFC - 2.5.4.645

# IfcProject
LongName: A2_HKR_katukaidesarja

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcColumn (4)
In: Site
Description: teräsputki 60x5

# IfcCovering (4)
In: Site
Description: RST -peitelevy

# IfcFastener (28)
In: Site
Name
12 x KIINNIKE | Description: RST -kiinnike
16 x MUTTERI

# IfcPlate, LAMINAATTI
In: Site
Description: Esim. Formica Compact Exterior / 8mm / väri PP 1202 U

# IfcRailing (20)
In: Site
Name | Description
SUOJARITILÄ | Neliötanko 20 x 20, väri RAL 6012
10 x SÄLEET | neliötanko 20 x 20, väri RAL 6012
2 x PÄÄTEHOLKKI | RST -putki 50 x4
2 x KAITEEN PÄÄTE | RST
YLÄJOHDE | RST -putki 42,4 x 3
4 x TOLPANPÄÄTE | latta 60x15
